PACKAGECONFIG[tslib] = "-no-tslib"
